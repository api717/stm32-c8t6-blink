# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  BeforeCompile: C:\Embedded\keil\ARM\ARMCC\bin\fromelf.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\drivers\inc;..\libraries\CMSIS\CM3\CoreSupport;..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\libraries\STM32F10x_StdPeriph_Driver\inc;..\user;..\public\inc;..\user\Application\Inc;..\user\System\inc;..\Hardware\Config;..\Hardware\drivers\inc;..\Middlewares\Inc;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group user
    ../user/: main.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
  group CMSIS
    ../libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group document
    ../document/: readme.txt
  group libraries
    ../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group drivers
    ../Hardware/drivers/src/: bsp_oled_debug.c LED_Init.c bsp_iic_debug.c Buzzer_init.c mq135_init.c DHT11_init.c esp_uart.c BSP_uart.c
  group public
    ../public/src/: system.c systick.c usart_drv.c
  group config
    ../Hardware/Config/: config.h Common_parameters.h
  group application
    ../user/Application/Src/: app_led.c app_oled.c app_buzzer.c app_mq135.c app_dht11.c
  group Hardware
    ../Hardware/: HardwareManage.c
